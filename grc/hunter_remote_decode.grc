options:
  parameters:
    generate_options: qt_gui
    id: hunter_remote_dec
    output_language: python
    title: Hunter Remote Decode
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '2500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(samp_rate/baud)
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '20'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.1'
    init: '0'
    low: '0.05'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '10101010101010101010101'
    tagname: msg_start
    threshold: '0'
    type: byte
  states: {}
- name: digital_correlate_access_code_tag_xx_0_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '100000000000000000000'
    tagname: msg_end
    threshold: '0'
    type: byte
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '0.75'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='Hunter Decoder',
                  in_sig=None,
                  out_sig=None
              )
              self.message_port_register_in(pmt.intern('msg_in'))
              self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)
              
          def handle_msg(self, msg):
              arr = list(pmt.to_python(msg)[1])
              msg_str = "".join([str(x) for x in arr])
              decoded = msg_str.replace("110", "A") \
                               .replace("100", "B") \
                               .replace("A", "1") \
                               .replace("B", "0")
            
              #print("msg = %s" % (msg_str))
              print("dec = %s" % (decoded))
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 433.92e6
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    axislabels: 'False'
    color1: '2'
    grid: 'True'
    gui_hint: (0, 2, 1, 2)
    name: '"Packet"'
    ncols: '220'
    samp_rate: '2500'
    type: msg_byte
    zmin: '0'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: (1, 0, 1, 4)
    label1: Threshold Signal
    label2: Sync Symbol
    name: '"Decoded Signals"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    tr_delay: '0.1'
    tr_level: '0.2'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"msg_end"'
    type: float
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: (0, 0, 1, 2)
    name: '"Spectrum"'
    type: complex
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {state: disabled}
- name: satellites_sync_to_pdu_0
  id: satellites_sync_to_pdu
  parameters:
    packlen: '198'
    sync: '"101010101010101010101010000000000000"'
    threshold: '0'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_sub_xx_0, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_threshold_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_2, '1']
- [blocks_sub_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_threshold_ff_0, '0', blocks_sub_xx_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0_2, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', satellites_sync_to_pdu_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', digital_correlate_access_code_tag_xx_0_0, '0']
- [digital_correlate_access_code_tag_xx_0_0, '0', blocks_uchar_to_float_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmosdr_source_0, '0', digital_symbol_sync_xx_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [satellites_sync_to_pdu_0, out, epy_block_0, msg_in]
- [satellites_sync_to_pdu_0, out, qtgui_time_raster_sink_x_0, in]
- [satellites_sync_to_pdu_0, out, satellites_hexdump_sink_0, in]

metadata:
  file_format: 1
